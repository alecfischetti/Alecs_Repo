<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
      <path>$WS_DIR$\lis3mdl_read.ewp</path>
  </project>
  <batchBuild/>
</workspace>


