<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
      <path>$WS_DIR$\bmi160_read.ewp</path>
  </project>
  <batchBuild/>
</workspace>


