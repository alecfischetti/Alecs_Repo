# IAR project data_plot.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: APOLLO512 AmbiqMicro APOLLO512
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; DEBUG_UTILS; AM_FREERTOS
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\src; ..\..\..\bsp; ..\..\..\..\..\utils; ..\..\..\..\..\devices; ..\..\..\..\..\mcu\apollo; ..\..\..\..\..; ..\..\..\..\..\third_party\FreeRTOS\Source\include; ..\..\..\..\..\third_party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\third_party\FreeRTOS\Source\portable\MemMang
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: data_plot.bin
  ILINK.IlinkOutputFile: data_plot.out
  ILINK.IlinkIcfFile: data_plot.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\mcu\apollo\hal\iar\bin\libam_hal.a; ..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; DEBUG_UTILS; AM_FREERTOS
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/: adxl362_task.c data_plot.c gpio_ctl.c iom_ctl.c rtos.c timer_ctl.c
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_plot.c am_util_ring_buffer.c am_util_stdio.c
    ../../../../../devices/: am_devices_adxl362.c
    ../../../../../third_party/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
    ../../../../../third_party/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ./: startup_iar.c
