# Keil uVision project data_plot.uvprojx, settings and files
target data_plot (ARM-ADS)
  device: Apollo 512 BGA Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.0.6.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: data_plot
  AfterMake: fromelf --bin --output bin\data_plot.bin bin\data_plot.axf
  AfterMake: fromelf -cedrst --output bin\data_plot.txt bin\data_plot.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: AM_PACKAGE_BGA DEBUG_UTILS AM_FREERTOS keil
  c include: ../src;../../../bsp;../../../../../utils;../../../../../devices;../../../../../mcu/apollo;../../../../..;../../../../../third_party/FreeRTOS/Source/include;../../../../../third_party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../third_party/FreeRTOS/Source/portable/MemMang
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  scatter file: .\data_plot.sct
  link misc: ../../../../../mcu/apollo/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: adxl362_task.c data_plot.c gpio_ctl.c iom_ctl.c rtos.c timer_ctl.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_plot.c am_util_ring_buffer.c am_util_stdio.c
  group devices
    ../../../../../devices/: am_devices_adxl362.c
  group keil
    ../keil/: startup_keil.s
  group Source
    ../../../../../third_party/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group ARM_CM4F
    ../../../../../third_party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group MemMang
    ../../../../../third_party/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group lib
    ../../../../../mcu/apollo/hal/keil/bin/: libam_hal.lib
    ../../../bsp/keil/bin/: libam_bsp.lib
