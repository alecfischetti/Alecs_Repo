# Keil uVision project adc_vbatt.uvprojx, settings and files
target adc_vbatt (ARM-ADS)
  device: Apollo 512 BGA Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.0.6.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: adc_vbatt
  AfterMake: fromelf --bin --output bin\adc_vbatt.bin bin\adc_vbatt.axf
  AfterMake: fromelf -cedrst --output bin\adc_vbatt.txt bin\adc_vbatt.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: AM_PACKAGE_BGA keil
  c include: ../src;../../../bsp;../../../../../devices;../../../../../utils;../../../../../mcu/apollo;../../../../..
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  scatter file: .\adc_vbatt.sct
  link misc: ../../../../../mcu/apollo/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: adc_vbatt.c
  group utils
    ../../../../../utils/: am_util_faultisr.c am_util_stdio.c
  group devices
    ../../../../../devices/: am_devices_led.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../mcu/apollo/hal/keil/bin/: libam_hal.lib
    ../../../bsp/keil/bin/: libam_bsp.lib
