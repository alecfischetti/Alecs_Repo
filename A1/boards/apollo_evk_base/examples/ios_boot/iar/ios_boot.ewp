# IAR project ios_boot.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: APOLLO512 AmbiqMicro APOLLO512
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\src; ..\..\..\bsp; ..\..\..\..\..\utils; ..\..\..\..\..\devices; ..\..\..\..\..\bootloader; ..\..\..\..\..\mcu\apollo; ..\..\..\..\..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ios_boot.bin
  ILINK.IlinkOutputFile: ios_boot.out
  ILINK.IlinkIcfFile: ios_boot.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\mcu\apollo\hal\iar\bin\libam_hal.a; ..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/: ios_boot.c
    ../../../../../utils/: am_util_delay.c
    ../../../../../bootloader/: am_bootloader.c
    ./: startup_iar.c
