<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
      <path>$WS_DIR$\iosi2c_hub.ewp</path>
  </project>
  <batchBuild/>
</workspace>


