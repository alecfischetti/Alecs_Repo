# IAR project ulpbench_lfrc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: APOLLO512 AmbiqMicro APOLLO512
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\src; ..\src\benchmarks; ..\src\benchmarks\CoreProfile; ..\src\TES; ..\src\Platforms\ARM\Board; ..\src\Platforms\ARM\Platform; ..\..\..\bsp; ..\..\..\..\..\utils; ..\..\..\..\..\devices; ..\..\..\..\..\mcu\apollo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ulpbench_lfrc.bin
  ILINK.IlinkOutputFile: ulpbench_lfrc.out
  ILINK.IlinkIcfFile: ulpbench_lfrc.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\mcu\apollo\hal\iar\bin\libam_hal.a; ..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA
  ICCARM.CCOptStrategy: 0
  group (top)
    ../src/benchmarks/CoreProfile/: CoreProfile.c lcd.c math_int.c permutation.c sort.c state.c
    ../src/TES/: TesEvents.c TesLists.c TesThreads.c TesTimers.c TesUtil.c
    ../src/Platforms/ARM/Board/: hardware_setup.c retarget.c
    ../src/Platforms/ARM/Platform/: Platform.c PlatformStackSwap.c
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_plot.c am_util_stdio.c
    ../../../../../devices/: am_devices_led.c
    ./: startup_iar.c
