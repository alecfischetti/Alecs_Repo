# Keil uVision project ulpbench_lfrc.uvprojx, settings and files
target ulpbench_lfrc (ARM-ADS)
  device: Apollo 512 BGA Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.0.6.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ulpbench_lfrc
  AfterMake: fromelf --bin --output bin\ulpbench_lfrc.bin bin\ulpbench_lfrc.axf
  AfterMake: fromelf -cedrst --output bin\ulpbench_lfrc.txt bin\ulpbench_lfrc.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: AM_PACKAGE_BGA keil
  c include: ../src;../src/benchmarks;../src/benchmarks/CoreProfile;../src/TES;../src/Platforms/ARM/Board;../src/Platforms/ARM/Platform;../../../bsp;../../../../../utils;../../../../../devices;../../../../../mcu/apollo
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  scatter file: .\ulpbench_lfrc.sct
  link misc: ../../../../../mcu/apollo/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group CoreProfile
    ../src/benchmarks/CoreProfile/: CoreProfile.c lcd.c math_int.c permutation.c sort.c state.c
  group TES
    ../src/TES/: TesEvents.c TesLists.c TesThreads.c TesTimers.c TesUtil.c
  group Board
    ../src/Platforms/ARM/Board/: hardware_setup.c retarget.c
  group Platform
    ../src/Platforms/ARM/Platform/: Platform.c PlatformStackSwap.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_plot.c am_util_stdio.c
  group devices
    ../../../../../devices/: am_devices_led.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../mcu/apollo/hal/keil/bin/: libam_hal.lib
    ../../../bsp/keil/bin/: libam_bsp.lib
