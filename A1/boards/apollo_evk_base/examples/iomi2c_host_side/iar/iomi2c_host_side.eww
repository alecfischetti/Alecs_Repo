<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
      <path>$WS_DIR$\iomi2c_host_side.ewp</path>
  </project>
  <batchBuild/>
</workspace>


