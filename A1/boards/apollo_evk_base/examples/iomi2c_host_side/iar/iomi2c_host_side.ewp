# IAR project iomi2c_host_side.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: APOLLO512 AmbiqMicro APOLLO512
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\src; ..\..\..\bsp; ..\..\..\..\..\utils; ..\..\..\..\..\devices; ..\..\..\..\..\mcu\apollo
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: iomi2c_host_side.bin
  ILINK.IlinkOutputFile: iomi2c_host_side.out
  ILINK.IlinkIcfFile: iomi2c_host_side.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\mcu\apollo\hal\iar\bin\libam_hal.a; ..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/: iomi2c_host_side.c iomi2c_host_side_driver.c
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ./: startup_iar.c
