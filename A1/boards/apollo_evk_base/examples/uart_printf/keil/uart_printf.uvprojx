# Keil uVision project uart_printf.uvprojx, settings and files
target uart_printf (ARM-ADS)
  device: Apollo 512 BGA Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.0.6.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uart_printf
  AfterMake: fromelf --bin --output bin\uart_printf.bin bin\uart_printf.axf
  AfterMake: fromelf -cedrst --output bin\uart_printf.txt bin\uart_printf.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: AM_PACKAGE_BGA keil
  c include: ../src;../../../bsp;../../../../../utils;../../../../../devices;../../../../../mcu/apollo;../../../../..
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  scatter file: .\uart_printf.sct
  link misc: ../../../../../mcu/apollo/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: uart_printf.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../mcu/apollo/hal/keil/bin/: libam_hal.lib
    ../../../bsp/keil/bin/: libam_bsp.lib
